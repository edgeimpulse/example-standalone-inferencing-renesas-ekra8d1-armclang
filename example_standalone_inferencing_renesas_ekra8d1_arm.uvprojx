# Keil uVision project example_standalone_inferencing_renesas_ekra8d1_arm.uvprojx, settings and files
target EK-RA8D1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.5.2.0
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: example_standalone_inferencing_renesas_ekra8d1_arm +hex
  BeforeMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out"""
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: EI_PORTING_RENESASRA8D1_KEIL=1, EI_MAX_OVERFLOW_BUFFER_COUNT=100
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal -Wno-c++98-compat -Wno-c++98-compat-pedantic
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via" --library_type=microlib
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.cpp ei_main.cpp ei_main.h
  group Edge Impulse
    ./: ei_classifier_porting.cpp
  group Peripheral
    ./peripheral/: led.c timer_handler.c uart_ep.c
software components: CMSIS:CORE 6.0.0, CMSIS:DSP 1.15.0, CMSIS:NN Lib 4.1.0, Flex Software:RA Configuration 1.0.0
